# IAR project SimpleBLECentral.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2472; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=TRUE; HAL_LED=TRUE; BLINK_LEDS; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=1; xUART_DEBUG=TRUE; xUART_POLLING=TRUE; USER_ISR_TRIGGER_UART; AUTO_CONNECT=TRUE; OAD_KEEP_NV_PAGES; HAL_KEY=FALSE; DEBUG_DUMP=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common\cc2540\cc254x_f256_myall.xcl
configuration CC2541EM_SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=TRUE; HAL_LED=TRUE; BLINK_LEDS; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=1; xUART_POLLING=TRUE; UART_DEBUG=FALSE; USER_ISR_TRIGGER_UART; AUTO_CONNECT=TRUE; MAKE_CRC_SHDW; FEATURE_SBL; OAD_KEEP_NV_PAGES; HAL_KEY=FALSE
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\blehex2bin.exe" "CC2541EM_SBL\Exe\SimpleBLECentral_SBL.hex" "CC2541EM_SBL\Exe\SimpleBLECentral_SBL.bin"  "CC2541EM_SBL\Exe\ble_fw.c"
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common\cc2540\cc254x_f256_sbl.xcl
  group APP
    ../Source/: des_algo.c des_algo.h gsensor_drv.c gsensor_drv.h i2c.c i2c.h mma8452q.h OSAL_simpleBLECentral.c Password.c Password.h pulse_drv.c pulse_drv.h sht20_drv.c sht20_drv.h simpleBLEApp.c simpleBLEApp.h simpleBLECentral.c simpleBLECentral.h simpleBLECentral_Main.c uart_app.c uart_app.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_i2c.c hal_i2c.h hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_cent.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: central.c central.h gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
